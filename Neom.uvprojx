# Keil uVision project Neom.uvprojx, settings and files
target Release (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Neom
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ./: main.cpp ITM_ARM.cpp RingBuffer.cpp
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Network:CORE 7.1.0, Network:Interface:ETH 7.1.0, Network:Legacy API 7.1.0, Network:Socket:BSD 7.1.0, Network:Socket:TCP 7.1.0, Network:Socket:UDP 7.1.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:LAN8720 6.1, CMSIS Driver:USART 2.4, Device:GPDMA 1.2, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
